# Keil uVision project evm_bearpi_stm32.uvprojx, settings and files
target evm_bearpi_stm32 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: evm_bearpi_stm32 +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx,USING_DEVICE_STM32L4
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\..\EVM;..\Bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../Src/: main.c gpio.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group EVM
    ../../EVM/: libejs.lib evm_main.c evm_module.c epolling_module.c evm_module_led.c evm_module_uart.c evm_module_adc.c evm_module_dac.c evm_module_pin.c evm_module_extint.c evm_module_rtc.c evm_module_timer.c evm_module_lcd.c evm_module_e53sc1.c evm_module_e53sf1.c evm_module_e53st1.c evm_module_e53ia1.c
  group BSP
    ../Bsp/uart/: usart.c
    ../Bsp/delay/: dwt_delay.c
    ../Bsp/led/: evm_led.c
    ../Bsp/adc/: adc.c
    ../Bsp/dac/: dac.c
    ../Bsp/LCD/: lcd.c
    ../Bsp/spi/: spi.c
    ../Bsp/E53_SC1/: E53_SC1.c
    ../Bsp/iic/: i2c.c
    ../Bsp/E53_SF1/: E53_SF1.c
    ../Bsp/tim/: tim.c
    ../Bsp/E53_ST1/: E53_ST1.c
    ../Bsp/E53_IA1/: E53_IA1.c
software components: CMSIS:CORE 4.3.0
